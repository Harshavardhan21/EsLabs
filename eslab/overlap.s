	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=DST
OL EQU 2
	MOV R1,#1
	MOV R2,#9
UP  STR R1,[R0]
	ADD R0,#4
	ADD R1,#2
	SUBS R2,#1
	BNE UP
	SUB R1,#(OL-1)*4
	MOV R2,#9
	MOV R3,#1
UP1 STR R2,[R1]
	ADD R1,#4
	ADD R3,#2
	SUBS R2,#1
	BNE UP1
STOP
	B STOP
SRC DCD 0
	AREA mydata,DATA,READWRITE
DST DCD 0
	END


	