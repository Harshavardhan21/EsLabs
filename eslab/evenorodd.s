	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R5,=NUM2
	LDR R9,=RESULT
	LDR R4,[R5]
	LDR R1,[R0]
	MOV R2,#0XA
	MOV R3,#0XF
LOOP
	CMP R1,R4
	BCC NEXT
	SUB R1,R4
	B LOOP
NEXT 
	CMP R1,#0
	BEQ NE
	STR R3,[R9]
HERE 
	B HERE
NE 
	STR R2,[R9]
STOP
	B STOP
NUM1 DCD 0X21
NUM2 DCD 0X2	
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END
	