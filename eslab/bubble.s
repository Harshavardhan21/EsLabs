	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM;
	MOV R2,#4;N
	MOV R3,#1;I
	LDR R9,=NUM
LOOP
	CMP R3,R2
	BEQ L1
	SUB R5,R2,R3
	MOV R8,R9
	MOV R10,R9
	MOV R6,#1
LOOP2
	CMP R6,R5
	ADDEQ R3,#1
	BHI LOOP
	LDR R4,[R8]
	ADD R8,#4
	LDR R7,[R8]
	CMP R4,R7
	BGT SWAP
	ADD R6,#1
	CMP R6,R5

	B LOOP2
SWAP
	MOV R12,R4
	MOV R4,R7
	MOV R7,R12
	SUB R8,#4
	STR R4,[R8]
	ADD R8,#4
	STR R7,[R8]
	ADD R8,#4
	B LOOP2
	
L1  B L1
STOP
	B STOP
NUM DCD 0x2,0x3,0x12,0x8,0x9
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END