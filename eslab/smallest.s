	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R1,[R0],#4
	LDR R2,=RESULT
	MOV R9,#5
LOOP
	LDR R3,[R0]
	CMP R1,R3
	BLT LESS
	MOV R1,R3
	
LESS
	ADD R0,#4
	SUB R9,#1
	CMP R9,#0
	BNE LOOP
	STR R1,[R2]
STOP
	B STOP
NUM DCD 0X12,0x3,0x5,0x10,0x9
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END
	