# Keil uVision project harsha.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: harsha
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: packtounpack.s hexatobcd.s bcdtoascii.s palindrome.s smallest.s add2-32bit.s mul2-32bit.s factorial.s evenorodd.s largest.s fibonacci.s bubble.s overlap.s arraysum.s untop.s
