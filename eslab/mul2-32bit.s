	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R9,=RESULT
	LDR R1,[R0]
	LDR R2,=NUM2
	LDR R3,[R2]
	UMULL R5,R6,R1,R3
	B RE
RE	LDR R4,=0XFF
	LSL R10,#8
	AND R8,R6,R4
	ORR R10,R8
	LSR R6,#8
	CMP R6,#0
	
	BNE RE
	STR R10,[R9],#1
	
	B REM
REM	
	LSL R11,#8
	AND R8,R5,R4
	ORR R11,R8
	LSR R5,#8
	CMP R5,#0
	BNE RE
	STR R11,[R9]
	

STOP
	B STOP
NUM1 DCD 0X12345
NUM2 DCD 0X12345
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END
	