# Keil uVision project check.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: check +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s led.c upcount.c smallest.s
    C:/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
    ./week6/: 8bitupcounter.c switchupdowncounter.c ring.c
    ./practise/: addtwonumbers.s
