	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R4,=NUM2
	LDR R7,=RESULT
	LDR R1,[R0]
	LDR R2,[R0]
	MOV R8,#0XAA
	MOV R9,#0XFF
	MOV R6,#0
	MOV R10,#10
LOOP
	AND R3,R1,#0X0000000F
	ADD R6,R3
	LSR R1,#4
	CMP R1,#0
	BEQ ST
	LSL R6,#4
	BNE LOOP
HERE 	
	B HERE
	
ST	
	CMP R2,R6
	BNE EN
	STR R8,[R7]
	
HER B HER

EN STR R9,[R7]	

STOP
	B STOP
NUM1 DCD 0X12
	
NUM2 DCD 0	
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END
	